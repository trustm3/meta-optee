require python-pyelftools.inc
inherit setuptools3
