PACKAGE_INSTALL += "\
	optee-test \
	optee-client \
"
